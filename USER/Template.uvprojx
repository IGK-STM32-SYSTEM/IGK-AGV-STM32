# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_USED=1,ARM_MATH_CM4,_CC_ARM
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\FWLIB\STM32F4xx_StdPeriph_Driver\inc;..\USER;..\HARDWARE\LED;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\uCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\PWM;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\timer2;..\HARDWARE\can;..\HARDWARE\capcount3;..\HARDWARE\capcount9;..\HARDWARE\cdhdata;..\HARDWARE\Modbus;..\HARDWARE\PID;..\HARDWARE\TLC5620;..\HARDWARE\usart;..\HARDWARE\yuyin;..\HARDWARE\Function;..\HARDWARE\IWDG;..\FWLIB\CMSIS\DSP_Lib\Source;..\HARDWARE\route;..\HARDWARE\read_PC;..\HARDWARE\Ethernet;..\HARDWARE\Ethernet\W5500;..\Robot;..\IGK
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group IGK
    ../IGK/: igk_dfs.c igk_drive.c igk_map.c igk_os.c igk_stack.c malloc.c
  group CORE
    ../CORE/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_tim.c stm32f4xx_spi.c stm32f4xx_can.c stm32f4xx_iwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/timer2/: timer2.c
    ../HARDWARE/can/: can.c
    ../HARDWARE/capcount3/: capcount3.c
    ../HARDWARE/capcount9/: capcount9.c
    ../HARDWARE/cdhdata/: cdhdata.c
    ../HARDWARE/Modbus/: Modbus_slave.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/TLC5620/: tlc5620.c
    ../HARDWARE/usart/: usart.c
    ../HARDWARE/yuyin/: xf.c
    ../HARDWARE/Function/: function.c
    ../HARDWARE/route/: route.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/read_PC/: read.c
    ../HARDWARE/Ethernet/: wizchip_conf.c socket.c
    ../HARDWARE/Ethernet/W5500/: w5500.c
  group UCOSIII_BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII_CPU
    ../UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../UCOSIII/uC-CPU/: cpu_core.c
  group UCOSIII_LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_c.c os_cpu_a.asm
  group UCOSIII_CONFIG
    ../UCOSIII/uCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
